<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MVP_2_freeRTOS.ewp</path>
  </project>
  <batchBuild />
</workspace>
